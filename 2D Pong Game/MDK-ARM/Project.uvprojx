# Keil uVision project Project.uvprojx, settings and files
target STM32746G_Discovery_ITCM-FLASH (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.13.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32746G_Discovery_ITCM-FLASH
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32746G-Discovery;../../../../Drivers/BSP/Components/Common;../../../../Drivers/BSP/Components/ft5336;../../../../Drivers/BSP/Components/ov9655;../../../../Drivers/BSP/Components/rk043fn48h;../../../../Drivers/BSP/Components/n25q128a;../../../../Drivers/BSP/Components/wm8994;../../../../Utilities/Log;../../../../Utilities/Fonts;../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Example/User
    ../Src/: stm32f7xx_it.c stm32f7xx_hal_msp.c main.c
  group Doc
    ../: readme.txt
target STM32746G_Discovery_AXIM-FLASH (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.13.0
  cpu: as above
  output: STM32746G_Discovery_AXIM-FLASH
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.4.0, Board Support:Drivers:Basic I/O 1.1.1, Board Support:Drivers:LCD 1.1.1, Board Support:Drivers:SDRAM 1.1.1, Board Support:Drivers:Touch Screen 1.1.1, Board Support:Touchscreen 1.1.1, Device:STM32Cube Framework:Classic 1.2.8, Device:STM32Cube HAL:Common 1.2.8, Device:STM32Cube HAL:Cortex 1.2.8, Device:STM32Cube HAL:DMA 1.2.8, Device:STM32Cube HAL:DMA2D 1.2.8, Device:STM32Cube HAL:GPIO 1.2.8, Device:STM32Cube HAL:I2C 1.2.8, Device:STM32Cube HAL:LTDC 1.2.8, Device:STM32Cube HAL:PWR 1.2.8, Device:STM32Cube HAL:RCC 1.2.8, Device:STM32Cube HAL:RNG 1.2.8, Device:STM32Cube HAL:SDRAM 1.2.8, Device:STM32Cube HAL:UART 1.2.8, Device:Startup 1.2.5
